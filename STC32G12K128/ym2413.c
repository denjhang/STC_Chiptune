/* ym2413.c - YM2413 (OPLL) FM 合成 (STC32G C251, 查表法)
 * 9 通道 2-operator FM, conv_vol[32][64] 预计算音量表
 * 参考: ArduinoUnoTinyFmKeyboard (ATmega328P) 查表 FM 技巧
 *
 * 核心优化:
 *   - conv_vol[level][sin_idx] 预计算 sin*level, 消除运行时乘法
 *   - 包络每 tick 只处理一个通道 (轮询分摊)
 *   - feedback 用移位代替除法
 */

#include "STC32G.H"
#include <string.h>
#include "ym2413.h"

/* ========== conv_vol: sin_value * level / 31, 预计算 [32][64] ========== */
/* conv_vol[level][sin_index] = sin(index) * level / 31 */
static const s8 ym_conv_vol[32][64] = {
    {0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0},
    {0,0,0,0,0,0,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0},
    {0,0,0,1,1,1,1,1,1,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,1,1,1,1,1,1,0,0,0,0,0,-1,-1,-1,-1,-1,-1,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-2,-1,-1,-1,-1,-1,-1,0,0},
    {0,0,1,1,1,1,2,2,2,2,3,3,3,3,3,3,3,3,3,3,3,3,3,2,2,2,2,1,1,1,1,0,0,0,-1,-1,-1,-1,-2,-2,-2,-2,-3,-3,-3,-3,-3,-3,-3,-3,-3,-3,-3,-3,-3,-2,-2,-2,-2,-1,-1,-1,-1,0},
    {0,0,1,1,2,2,2,3,3,3,3,3,4,4,4,4,4,4,4,4,4,3,3,3,3,3,2,2,2,1,1,0,0,0,-1,-1,-2,-2,-2,-3,-3,-3,-3,-3,-4,-4,-4,-4,-4,-4,-4,-4,-4,-3,-3,-3,-3,-3,-2,-2,-2,-1,-1,0},
    {0,0,1,1,2,2,3,3,4,4,4,4,5,5,5,5,5,5,5,5,5,4,4,4,4,3,3,2,2,1,1,0,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-4,-4,-5,-5,-5,-5,-5,-5,-5,-5,-5,-4,-4,-4,-4,-3,-3,-2,-2,-1,-1,0},
    {0,1,1,2,2,3,3,4,4,5,5,5,6,6,6,6,6,6,6,6,6,5,5,5,4,4,3,3,2,2,1,1,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-5,-6,-6,-6,-6,-6,-6,-6,-6,-6,-5,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1},
    {0,1,1,2,3,3,4,5,5,5,6,6,7,7,7,7,7,7,7,7,7,6,6,5,5,5,4,3,3,2,1,1,0,-1,-1,-2,-3,-3,-4,-5,-5,-5,-6,-6,-7,-7,-7,-7,-7,-7,-7,-7,-7,-6,-6,-5,-5,-5,-4,-3,-3,-2,-1,-1},
    {0,1,2,2,3,4,4,5,6,6,7,7,7,8,8,8,8,8,8,8,7,7,7,6,6,5,4,4,3,2,2,1,0,-1,-2,-2,-3,-4,-4,-5,-6,-6,-7,-7,-7,-8,-8,-8,-8,-8,-8,-8,-7,-7,-7,-6,-6,-5,-4,-4,-3,-2,-2,-1},
    {0,1,2,3,3,4,5,6,6,7,8,8,8,9,9,9,9,9,9,9,8,8,8,7,6,6,5,4,3,3,2,1,0,-1,-2,-3,-3,-4,-5,-6,-6,-7,-8,-8,-8,-9,-9,-9,-9,-9,-9,-9,-8,-8,-8,-7,-6,-6,-5,-4,-3,-3,-2,-1},
    {0,1,2,3,4,5,5,6,7,8,8,9,9,10,10,10,10,10,10,10,9,9,8,8,7,6,5,5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-6,-7,-8,-8,-9,-9,-10,-10,-10,-10,-10,-10,-10,-9,-9,-8,-8,-7,-6,-5,-5,-4,-3,-2,-1},
    {0,1,2,3,4,5,6,7,8,9,9,10,10,11,11,11,11,11,11,11,10,10,9,9,8,7,6,5,4,3,2,1,0,-1,-2,-3,-4,-5,-6,-7,-8,-9,-9,-10,-10,-11,-11,-11,-11,-11,-11,-11,-10,-10,-9,-9,-8,-7,-6,-5,-4,-3,-2,-1},
    {0,1,2,3,5,6,7,8,9,9,10,10,11,12,12,12,12,12,12,12,11,10,10,9,9,8,7,6,5,3,2,1,0,-1,-2,-3,-5,-6,-7,-8,-9,-9,-10,-10,-11,-12,-12,-12,-12,-12,-12,-12,-11,-10,-10,-9,-9,-8,-7,-6,-5,-3,-2,-1},
    {0,1,3,4,5,6,7,8,9,10,11,11,12,13,13,13,13,13,13,13,12,11,11,10,9,8,7,6,5,4,3,1,0,-1,-3,-4,-5,-6,-7,-8,-9,-10,-11,-11,-12,-13,-13,-13,-13,-13,-13,-13,-12,-11,-11,-10,-9,-8,-7,-6,-5,-4,-3,-1},
    {0,1,3,4,5,7,8,9,10,11,12,12,13,14,14,14,14,14,14,14,13,12,12,11,10,9,8,7,5,4,3,1,0,-1,-3,-4,-5,-7,-8,-9,-10,-11,-12,-12,-13,-14,-14,-14,-14,-14,-14,-14,-13,-12,-12,-11,-10,-9,-8,-7,-5,-4,-3,-1},
    {0,1,3,4,6,7,8,10,11,12,13,13,14,15,15,15,15,15,15,15,14,13,13,12,11,10,8,7,6,4,3,1,0,-1,-3,-4,-6,-7,-8,-10,-11,-12,-13,-13,-14,-15,-15,-15,-15,-15,-15,-15,-14,-13,-13,-12,-11,-10,-8,-7,-6,-4,-3,-1},
    {0,2,3,5,6,8,9,10,11,12,13,14,15,15,15,16,16,16,15,15,15,14,13,12,11,10,9,8,6,5,3,2,0,-2,-3,-5,-6,-8,-9,-10,-11,-12,-13,-14,-15,-15,-15,-16,-16,-16,-15,-15,-15,-14,-13,-12,-11,-10,-9,-8,-6,-5,-3,-2},
    {0,2,3,5,7,8,9,11,12,13,14,15,16,16,16,17,17,17,16,16,16,15,14,13,12,11,9,8,7,5,3,2,0,-2,-3,-5,-7,-8,-9,-11,-12,-13,-14,-15,-16,-16,-16,-17,-17,-17,-16,-16,-16,-15,-14,-13,-12,-11,-9,-8,-7,-5,-3,-2},
    {0,2,3,5,7,9,10,12,13,14,15,16,17,17,17,18,18,18,17,17,17,16,15,14,13,12,10,9,7,5,3,2,0,-2,-3,-5,-7,-9,-10,-12,-13,-14,-15,-16,-17,-17,-17,-18,-18,-18,-17,-17,-17,-16,-15,-14,-13,-12,-10,-9,-7,-5,-3,-2},
    {0,2,4,6,7,9,10,12,13,15,16,17,18,18,18,19,19,19,18,18,18,17,16,15,13,12,10,9,7,6,4,2,0,-2,-4,-6,-7,-9,-10,-12,-13,-15,-16,-17,-18,-18,-18,-19,-19,-19,-18,-18,-18,-17,-16,-15,-13,-12,-10,-9,-7,-6,-4,-2},
    {0,2,4,6,8,10,11,13,14,15,17,17,19,19,19,20,20,20,19,19,19,17,17,15,14,13,11,10,8,6,4,2,0,-2,-4,-6,-8,-10,-11,-13,-14,-15,-17,-17,-19,-19,-19,-20,-20,-20,-19,-19,-19,-17,-17,-15,-14,-13,-11,-10,-8,-6,-4,-2},
    {0,2,4,6,8,10,12,14,15,16,18,18,20,20,20,21,21,21,20,20,20,18,18,16,15,14,12,10,8,6,4,2,0,-2,-4,-6,-8,-10,-12,-14,-15,-16,-18,-18,-20,-20,-20,-21,-21,-21,-20,-20,-20,-18,-18,-16,-15,-14,-12,-10,-8,-6,-4,-2},
    {0,2,4,6,9,11,12,14,16,17,18,19,21,21,21,22,22,22,21,21,21,19,18,17,16,14,12,11,9,6,4,2,0,-2,-4,-6,-9,-11,-12,-14,-16,-17,-18,-19,-21,-21,-21,-22,-22,-22,-21,-21,-21,-19,-18,-17,-16,-14,-12,-11,-9,-6,-4,-2},
    {0,2,4,7,9,11,13,15,16,18,19,20,22,22,22,23,23,23,22,22,22,20,19,18,16,15,13,11,9,7,4,2,0,-2,-4,-7,-9,-11,-13,-15,-16,-18,-19,-20,-22,-22,-22,-23,-23,-23,-22,-22,-22,-20,-19,-18,-16,-15,-13,-11,-9,-7,-4,-2},
    {0,2,5,7,9,12,13,15,17,19,20,21,22,23,23,24,24,24,23,23,22,21,20,19,17,15,13,12,9,7,5,2,0,-2,-5,-7,-9,-12,-13,-15,-17,-19,-20,-21,-22,-23,-23,-24,-24,-24,-23,-23,-22,-21,-20,-19,-17,-15,-13,-12,-9,-7,-5,-2},
    {0,2,5,7,10,12,14,16,18,19,21,22,23,24,24,25,25,25,24,24,23,22,21,19,18,16,14,12,10,7,5,2,0,-2,-5,-7,-10,-12,-14,-16,-18,-19,-21,-22,-23,-24,-24,-25,-25,-25,-24,-24,-23,-22,-21,-19,-18,-16,-14,-12,-10,-7,-5,-2},
    {0,3,5,8,10,13,14,17,18,20,22,23,24,25,25,26,26,26,25,25,24,23,22,20,18,17,14,13,10,8,5,3,0,-3,-5,-8,-10,-13,-14,-17,-18,-20,-22,-23,-24,-25,-25,-26,-26,-26,-25,-25,-24,-23,-22,-20,-18,-17,-14,-13,-10,-8,-5,-3},
    {0,3,5,8,10,13,15,17,19,21,23,24,25,26,26,27,27,27,26,26,25,24,23,21,19,17,15,13,10,8,5,3,0,-3,-5,-8,-10,-13,-15,-17,-19,-21,-23,-24,-25,-26,-26,-27,-27,-27,-26,-26,-25,-24,-23,-21,-19,-17,-15,-13,-10,-8,-5,-3},
    {0,3,5,8,11,14,15,18,20,22,23,24,26,27,27,28,28,28,27,27,26,24,23,22,20,18,15,14,11,8,5,3,0,-3,-5,-8,-11,-14,-15,-18,-20,-22,-23,-24,-26,-27,-27,-28,-28,-28,-27,-27,-26,-24,-23,-22,-20,-18,-15,-14,-11,-8,-5,-3},
    {0,3,6,8,11,14,16,19,21,22,24,25,27,28,28,29,29,29,28,28,27,25,24,22,21,19,16,14,11,8,6,3,0,-3,-6,-8,-11,-14,-16,-19,-21,-22,-24,-25,-27,-28,-28,-29,-29,-29,-28,-28,-27,-25,-24,-22,-21,-19,-16,-14,-11,-8,-6,-3},
    {0,3,6,9,12,15,16,19,21,23,25,26,28,29,29,30,30,30,29,29,28,26,25,23,21,19,16,15,12,9,6,3,0,-3,-6,-9,-12,-15,-16,-19,-21,-23,-25,-26,-28,-29,-29,-30,-30,-30,-29,-29,-28,-26,-25,-23,-21,-19,-16,-15,-12,-9,-6,-3},
    {0,3,6,9,12,15,17,20,22,24,26,27,29,30,30,31,31,31,30,30,29,27,26,24,22,20,17,15,12,9,6,3,0,-3,-6,-9,-12,-15,-17,-20,-22,-24,-26,-27,-29,-30,-30,-31,-31,-31,-30,-30,-29,-27,-26,-24,-22,-20,-17,-15,-12,-9,-6,-3}
};

/* ========== 内置音色参数 (15 个) ========== */
typedef struct {
    u8 mul_m, tl_m, fb, ar_m, dr_m, sl_m;
    u8 mul_c, ar_c, dr_c, sl_c;
} YM_PATCH;

static const YM_PATCH ym_builtin[16] = {
    {1,  0, 0, 15,  0,  0,  1, 15,  0,  0},  /* 0: User */
    {1,  2, 0, 15,  7,  1,  1, 15,  7,  1},  /* 1: Violin */
    {4,  2, 0, 12,  5,  2,  1, 12,  5,  2},  /* 2: Guitar */
    {4,  2, 0, 15,  5,  3,  1, 15,  5,  3},  /* 3: Piano */
    {1,  3, 0, 10,  4,  2,  1, 10,  4,  2},  /* 4: Flute */
    {1,  2, 0, 11,  5,  2,  1, 11,  5,  2},  /* 5: Clarinet */
    {1,  2, 0, 13,  5,  1,  1, 13,  5,  1},  /* 6: Oboe */
    {1,  1, 0, 15,  4,  1,  1, 15,  4,  1},  /* 7: Trumpet */
    {1,  2, 0, 12,  0,  3,  1, 12,  0,  3},  /* 8: Organ */
    {1,  2, 0, 10,  4,  2,  1, 10,  4,  2},  /* 9: Horn */
    {3,  2, 1, 15,  5,  1,  1, 15,  5,  1},  /* A: Synth */
    {1,  0, 0, 15,  3,  1,  1, 15,  3,  1},  /* B: Harmonics */
    {1,  2, 0, 12,  5,  3,  1, 12,  5,  3},  /* C: Vibraphone */
    {5,  0, 0, 15,  5,  0,  1, 15,  5,  0},  /* D: Synth Bass */
    {5,  0, 0, 15,  7,  0,  1, 15,  7,  0},  /* E: Acoustic Bass */
    {4,  1, 0, 15,  5,  1,  1, 15,  5,  1},  /* F: Electric Guitar */
};

/* ========== 通道状态 (紧凑布局) ========== */
typedef struct {
    u16 phase_m, phase_c;
    u16 step;
    u8  key, sustain_flag;
    u8  fb, fb_val;
    u8  mul_m, tl_m;
    u8  env_state_m, env_cnt_m, env_step_m, env_level_m, sl_m;
    u8  mul_c, vol;
    u8  env_state_c, env_cnt_c, env_step_c, env_level_c, sl_c;
    u8  patch;
} YM_CHAN;

static YM_CHAN ym_ch[YM_CHANS];
static u8  ym_regs[0x40];
static u8  ym_rhythm;
static u8  ym_user_patch[8];
static u8  ym_env_rr;  /* envelope round-robin counter */

/* ========== ADSR 速率表 ========== */
static const u8 ym_rate_table[16] = {
     0,  1,  2,  3,  4,  6,  8, 12,
    16, 24, 32, 48, 64, 96,128,255
};

/* ========== 初始化 ========== */
void ym_init(void) {
    u8 i;
    memset(ym_regs, 0, sizeof(ym_regs));
    ym_rhythm = 0;
    ym_env_rr = 0;
    memset(ym_user_patch, 0, sizeof(ym_user_patch));

    for (i = 0; i < YM_CHANS; i++) {
        YM_CHAN *c = &ym_ch[i];
        c->phase_m = 0;
        c->phase_c = 0;
        c->step = 0;
        c->key = 0;
        c->sustain_flag = 0;
        c->fb = 0;
        c->fb_val = 0;
        c->mul_m = 1;
        c->tl_m = 0;
        c->env_state_m = 0;
        c->env_cnt_m = 0;
        c->env_step_m = 0;
        c->env_level_m = 0;
        c->sl_m = 0;
        c->mul_c = 1;
        c->vol = 0;
        c->env_state_c = 0;
        c->env_cnt_c = 0;
        c->env_step_c = 0;
        c->env_level_c = 0;
        c->sl_c = 0;
        c->patch = 0;
    }
}

/* ========== 应用音色到通道 ========== */
static void ym_apply_patch(u8 ch) {
    YM_CHAN *c = &ym_ch[ch];
    const YM_PATCH *p = &ym_builtin[c->patch == 0 ? 0 : c->patch];

    c->mul_m = p->mul_m;
    c->tl_m = p->tl_m;
    c->fb = p->fb;
    c->sl_m = p->sl_m;
    c->mul_c = p->mul_c;
    c->sl_c = p->sl_c;
}

/* ========== Key On/Off ========== */
static void ym_key_on(u8 ch) {
    YM_CHAN *c = &ym_ch[ch];
    const YM_PATCH *p = &ym_builtin[c->patch == 0 ? 0 : c->patch];

    if (ch >= YM_CHANS) return;
    c->key = 1;
    c->phase_m = 0;
    c->phase_c = 0;
    c->fb_val = 0;

    c->env_state_m = 1;
    c->env_cnt_m = 0;
    c->env_level_m = 0;
    c->env_step_m = ym_rate_table[p->ar_m & 0x0F];

    c->env_state_c = 1;
    c->env_cnt_c = 0;
    c->env_level_c = 0;
    c->env_step_c = ym_rate_table[p->ar_c & 0x0F];
}

static void ym_key_off(u8 ch) {
    YM_CHAN *c = &ym_ch[ch];
    if (ch >= YM_CHANS) return;
    if (c->key) {
        c->key = 0;
        if (c->env_state_m > 0 && c->env_state_m < 4) {
            c->env_state_m = 4;
            c->env_step_m = ym_rate_table[1];
        }
        if (c->env_state_c > 0 && c->env_state_c < 4) {
            c->env_state_c = 4;
            c->env_step_c = ym_rate_table[1];
        }
    }
}

/* ========== 包络更新 (单 operator) ========== */
static void ym_update_env(u8 *state, u8 *cnt, u8 *step, u8 sl, u8 *level) {
    if (*state == 0) return;

    *cnt += *step;
    if (*cnt < *step) {
        *cnt = 0;
        switch (*state) {
        case 1:
            if (*level < 31) (*level)++;
            if (*level >= 31) *state = 2;
            break;
        case 2:
            if (*level > sl) (*level)--;
            else *state = 3;
            break;
        case 3:
            if (*level > 0) (*level)--;
            if (*level == 0) *state = 0;
            break;
        case 4:
            if (*level > 0) (*level)--;
            if (*level == 0) *state = 0;
            break;
        }
    }
}

/* ========== 寄存器写入 ========== */
void ym_wr(u8 reg, u8 val) {
    u8 ch, fnum, block;
    u16 step;

    if (reg > 0x3F) return;
    ym_regs[reg] = val;

    switch (reg & 0xF0) {
    case 0x00:
        if (reg < 8) ym_user_patch[reg] = val;
        break;

    case 0x10:
        ch = reg & 0x0F;
        if (ch >= YM_CHANS) break;
        fnum = val;
        block = (ym_regs[0x20 + ch] >> 1) & 0x07;
        step = (u16)fnum << (block > 4 ? 4 : block);
        {
            YM_CHAN *c = &ym_ch[ch];
            u8 mul = c->mul_c ? c->mul_c : 1;
            c->step = step * mul;
        }
        break;

    case 0x20:
        ch = reg & 0x0F;
        if (ch >= YM_CHANS) break;
        ym_ch[ch].sustain_flag = (val >> 5) & 1;
        fnum = ((val & 0x01) << 8) | ym_regs[0x10 + ch];
        block = (val >> 1) & 0x07;
        step = (u16)fnum << (block > 4 ? 4 : block);
        {
            YM_CHAN *c = &ym_ch[ch];
            u8 mul = c->mul_c ? c->mul_c : 1;
            c->step = step * mul;
        }
        if (val & 0x10) ym_key_on(ch);
        else ym_key_off(ch);
        break;

    case 0x30:
        ch = reg & 0x0F;
        if (ch >= YM_CHANS) break;
        {
            YM_CHAN *c = &ym_ch[ch];
            u8 new_patch = (val >> 4) & 0x0F;
            if (new_patch != c->patch) {
                c->patch = new_patch;
                ym_apply_patch(ch);
                fnum = ((ym_regs[0x20 + ch] & 0x01) << 8) | ym_regs[0x10 + ch];
                block = (ym_regs[0x20 + ch] >> 1) & 0x07;
                step = (u16)fnum << (block > 4 ? 4 : block);
                {
                    u8 mul = c->mul_c ? c->mul_c : 1;
                    c->step = step * mul;
                }
            }
            c->vol = val & 0x0F;
        }
        break;

    case 0x0E:
        if (reg == 0x0E) ym_rhythm = val;
        break;
    }
}

/* ========== 渲染 (查表法, 无乘法) ========== */
s16 ym_render(void) {
    s16 mix;
    u8 ch, idx_m, idx_c;
    s8 mod_out;
    YM_CHAN *c;

    mix = 0;

    /* 包络 round-robin: 每 tick 只处理一个通道的包络 */
    ch = ym_env_rr;
    ym_env_rr = (ym_env_rr + 1) & 7;  /* 0..8 cycle, 9 channels */
    if (ch < YM_CHANS) {
        c = &ym_ch[ch];
        if (c->env_state_m > 0 || c->key) {
            if (c->env_state_m == 2) {
                const YM_PATCH *p = &ym_builtin[c->patch == 0 ? 0 : c->patch];
                c->env_step_m = ym_rate_table[p->dr_m & 0x0F];
            }
            ym_update_env(&c->env_state_m, &c->env_cnt_m, &c->env_step_m,
                          c->sl_m, &c->env_level_m);
        }
        if (c->env_state_c > 0 || c->key) {
            if (c->env_state_c == 2) {
                const YM_PATCH *p = &ym_builtin[c->patch == 0 ? 0 : c->patch];
                c->env_step_c = ym_rate_table[p->dr_c & 0x0F];
            }
            ym_update_env(&c->env_state_c, &c->env_cnt_c, &c->env_step_c,
                          c->sl_c, &c->env_level_c);
        }
    }

    /* 所有活跃通道: phase + waveform lookup */
    for (ch = 0; ch < YM_CHANS; ch++) {
        c = &ym_ch[ch];

        if (c->env_state_c == 0 && c->env_state_m == 0) continue;

        /* phase 累加 */
        c->phase_m += c->step * (c->mul_m ? c->mul_m : 1);
        c->phase_c += c->step;

        /* OP1 (modulator): phase → conv_vol lookup */
        idx_m = (c->phase_m >> 10) & 0x3F;
        idx_m = (idx_m + c->fb_val) & 0x3F;
        mod_out = ym_conv_vol[c->env_level_m][idx_m];

        /* feedback: mod_out * fb >> 4 (shift only, no multiply) */
        if (c->fb > 0) {
            c->fb_val = (u8)((s16)mod_out * c->fb >> 4);
        } else {
            c->fb_val = 0;
        }

        /* OP2 (carrier): phase + mod → conv_vol lookup */
        idx_c = (c->phase_c >> 10) & 0x3F;
        idx_c = (idx_c + mod_out) & 0x3F;

        /* conv_vol[carrier_level][idx] gives sin*level/31 */
        /* then apply channel volume: >> (4 - vol_bits) ≈ shift */
        {
            s8 carrier = ym_conv_vol[c->env_level_c][idx_c];
            /* vol 0-15, scale: carrier * (15-vol) / 15 ≈ carrier >> shift */
            /* use lookup: vol_shift[16] = {0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8} */
            /* simpler: (carrier * (16-vol)) >> 4 — one multiply, but small */
            mix += (s16)carrier * (16 - c->vol) >> 2;
        }
    }

    return mix;
}
